PACKAGECONFIG += " \
    accessibility \
    eglfs \
    examples \
    fontconfig \
    gles2 \
    libinput \
    linuxfb \
    tools \
    tslib \
    "
    
DEPENDS += "userland"